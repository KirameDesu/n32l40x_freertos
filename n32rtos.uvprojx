# Keil uVision project n32rtos.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm compier 5)
  device: N32L406CB Nationstech
  pack: Nationstech.N32L40x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x4000) IRAM2(0x20006000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: n32rtos
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\os\include;.\os\portable;.\Base_Driver\inc;.\inc;.\CMSIS\device;.\CMSIS\core
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20006000 size 0x2000
  group os
    ./os/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./os/portable/: port.c
    ./os/MemMang/: heap_4.c
  group Base_core
    ./CMSIS/device/startup/: startup_n32l40x.s
    ./CMSIS/device/: system_n32l40x.c
  group Base_driver
    ./Base_Driver/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_usart.c n32l40x_wwdg.c
  group src
    ./src/: main.c n32l40x_it.c led.c uart.c
